# Keil uVision project L4.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: L4 +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: main.c
  group driver
    ./: SMG.c button.c
